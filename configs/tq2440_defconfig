## configs/tq2440_defconfig
```kconfig
CONFIG_ARM=y
CONFIG_TARGET_TQ2440=y
CONFIG_SYS_PROMPT="TQ2440 # "
# CONFIG_CMD_SETEXPR is not set
```
